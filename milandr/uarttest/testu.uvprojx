# Keil uVision project testu.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MDR1986BE92 Milandr
  pack: Keil.MDR1986BExx.1.51
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: testu +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\MLT
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c U_Uart.h U_Uart.c
  group mlt
    ../MLT/: mlt_lcd.c
software components: Device:Startup 1.5, Drivers:ADC 1.5, Drivers:COMP 1.5, Drivers:PORT 1.5, Drivers:RST_CLK 1.5, Drivers:UART 1.5
